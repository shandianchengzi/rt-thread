# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F429BITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: RT_USING_LIBC, __STDC_LIMIT_MACROS, __CLK_TCK=RT_TICK_PER_SECOND, USE_HAL_DRIVER, RT_USING_ARMLIBC, __RTTHREAD__, STM32F429xx
  c include: ..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\components\net\sal\include;packages\cJSON-v1.7.17;packages\pahomqtt-latest\MQTTClient-RT;..\..\..\components\net\at\at_socket;..\..\..\components\drivers\include;..\..\..\libcpu\arm\common;board;..\..\..\components\libc\compilers\common\include;packages\at_device-latest\inc;..\libraries\HAL_Drivers\CMSIS\Include;..\..\..\components\net\lwip\lwip-2.0.3\src\include\ipv4;..\libraries\HAL_Drivers\drivers\config;..\..\..\components\drivers\include;packages\pahomqtt-latest\MQTTPacket\src;..\..\..\components\net\sal\include\dfs_net;packages\at_device-latest\class\esp8266;..\..\..\components\libc\compilers\common\extension;..\..\..\components\libc\posix\io\eventfd;..\..\..\components\net\sal\impl;..\libraries\HAL_Drivers\drivers;..\libraries\STM32F4xx_HAL\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\components\net\at\include;..\..\..\components\finsh;..\..\..\components\net\lwip\lwip-2.0.3\src\include;..\..\..\components\net\lwip\lwip-2.0.3\src\include\netif;.;..\libraries\HAL_Drivers;..\..\..\components\utilities\resource;..\..\..\include;..\..\..\components\net\lwip\port;board\ports;..\..\..\components\libc\posix\ipc;board\CubeMX_Config\Inc;..\..\..\components\libc\posix\io\poll;..\libraries\STM32F4xx_HAL\STM32F4xx_HAL_Driver\Inc;..\..\..\components\dfs\dfs_v1\include;packages\aht10-latest;applications;..\..\..\components\drivers\include;..\..\..\libcpu\arm\cortex-m4;..\..\..\components\net\sal\include\socket\sys_socket;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\net\netdev\include;..\..\..\components\libc\posix\io\epoll;..\..\..\components\dfs\dfs_v1\filesystems\devfs;..\..\..\components\net\sal\include\socket
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  group aht10
    packages/aht10-latest/: aht10.c
  group Applications
    applications/: main.c
  group AT
    ../../../components/net/at/src/: at_cli.c at_client.c at_utils.c
    ../../../components/net/at/at_socket/: at_socket.c
  group at_device
    packages/at_device-latest/src/: at_device.c
    packages/at_device-latest/samples/: at_sample_esp8266.c
    packages/at_device-latest/class/esp8266/: at_device_esp8266.c at_socket_esp8266.c
  group cJSON
    packages/cJSON-v1.7.17/: cJSON_Utils.c cJSON.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/i2c/: i2c-bit-ops.c i2c_core.c i2c_dev.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/pin/: pin.c
    ../../../components/drivers/serial/: serial.c
  group Drivers
    ../libraries/HAL_Drivers/drivers/: drv_gpio.c drv_soft_i2c.c drv_usart.c
    ../libraries/HAL_Drivers/: drv_common.c
    ../libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429xx.s
    board/CubeMX_Config/Src/: stm32f4xx_hal_msp.c
    board/: board.c
    board/ports/: drv_ext_io.c
  group Filesystem
    ../../../components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    ../../../components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../../../components/finsh/: shell.c cmd.c msh_file.c msh.c msh_parse.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
    ../../../src/klibc/: kstdio.c kstring.c
  group libcpu
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group Libraries
    ../libraries/STM32F4xx_HAL/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rng.c stm32f4xx_hal_sram.c stm32f4xx_hal.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_uart.c stm32f4xx_hal_crc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_i2c.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_pwr.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_usart.c stm32f4xx_hal_cec.c stm32f4xx_hal_cryp.c
    ../libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group lwIP
    ../../../components/net/lwip/lwip-2.0.3/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../components/net/lwip/lwip-2.0.3/src/apps/ping/: ping.c
    ../../../components/net/lwip/lwip-2.0.3/src/core/: def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../components/net/lwip/lwip-2.0.3/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../components/net/lwip/lwip-2.0.3/src/netif/: ethernet.c lowpan6.c
    ../../../components/net/lwip/port/: ethernetif.c sys_arch.c
  group paho-mqtt
    packages/pahomqtt-latest/MQTTPacket/src/: MQTTSerializePublish.c MQTTFormat.c MQTTUnsubscribeServer.c MQTTConnectClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTPacket.c MQTTSubscribeClient.c MQTTDeserializePublish.c MQTTConnectServer.c
    packages/pahomqtt-latest/MQTTClient-RT/: paho_mqtt_pipe.c
  group POSIX
    ../../../components/libc/posix/io/poll/: poll.c select.c
  group SAL
    ../../../components/net/netdev/src/: netdev.c netdev_ipaddr.c
    ../../../components/net/sal/dfs_net/: dfs_net.c
    ../../../components/net/sal/impl/: af_inet_at.c af_inet_lwip.c
    ../../../components/net/sal/socket/: net_netdb.c net_sockets.c
    ../../../components/net/sal/src/: sal_socket.c
  group Utilities
    ../../../components/utilities/resource/: resource_id.c
